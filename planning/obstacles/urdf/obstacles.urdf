Commit message: collision free planning

File: planning/obstacles/urdf/obstacles.urdf (robot description, URDF)
Before this commit: robot obstacles, 1 links, 0 joints
Links:
- link base_link: mass 18 -> 3

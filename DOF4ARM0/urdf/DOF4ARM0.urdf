Commit message: new robot arm

File: DOF4ARM0/urdf/DOF4ARM0.urdf (robot description, URDF)
Before this commit: robot DOF4ARM0, 5 links, 4 joints
Joints:
- joint L1_L2: axis 0 1 0 -> 0 -1 0
- joint L2_L3: axis 0 1 0 -> 0 -1 0
- joint L3_L4: axis 1 0 0 -> -1 0 0
